FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://imx219.cfg"